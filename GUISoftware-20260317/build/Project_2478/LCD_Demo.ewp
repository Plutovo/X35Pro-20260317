# IAR project LCD_Demo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: ; ..\..\Application; ..\..\Application\language; ..\..\board\include; ..\..\board\device\inc; ..\..\gui\wm; ..\..\gui\core; ..\..\guiconfig; ..\..\gui\Widget; ..\..\config; ..\..\gui\Font; ..\..\Application\Check_include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: LCD_Demo.hex
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkConfigDefines: IAR_LPC_2478_STK_LINK=1; IAR_LPC_1788_STK_LINK=0
  ILINK.IlinkIcfFile: Config\LPC1788 and 2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Application/: AddFunETCO2.c Alarm_Handle.c Alarm_handle.h ButtonExCtrl.c ButtonExCtrlA.c ButtonRotation.c ButtonRotation.h ButtonRotationEx.c C002_CO2.c Calibration_Protocol.c Calibration_Protocol.h cbdialog32.h CO2_IRMA.h Communication_Handle.c DATA_FRAME.c DATA_FRAME.h Data_Handle.c des.c des.h DrawEffectLine.c DrawEffectLine.h ImageText.c IMAGETEXT.h ImageText_Private.h JM1_SpO2.c Key_Handle.c KeyBoard.c KeyBoard.h MainTask.C MultiPage_Button.c phasein_CO2_IRMA.C POWER_INFO.c POWER_INFO.h Process_Widget.c queue_manul.c RectInfoCtrl.c RectPaintCtrl.c Skinning_Lib.H SkinningLib.c Static_Menu_creat.c TextExCtrl.c TouchScreenCalibrate.c TracingCurve.c TracingCurveEx.c TrendApplication.c TrendTable.c TrendTable.h WIDGET_Multipage.c WIDGET_Progbar.c
    ../../board/: Interrupt.c main.c
  group Application/Check_include
    ../../Application/Check_include/: context_app.h display_app.h error_app.h finish_app.h memory_app.h protocol_app.h resource_app.h serial_app.h system_app.h
  group Application/Check_source
    ../../Application/Check_source/: air_supply_app.c barometer_app.c battery_app.c Circuit_Compliance_app.c Circuit_Leakage_app.c context_app.c display_app.c error_app.c finish_app.c flow_sensor_app.c initialization_app.c main_app.c Manual_app.c memory_app.c Oxygen_sensor_app.c pressure_sensor_app.c resource_app.c serial_app.c
  group Application/icon
    ../../Application/icon/: ac_icon.c batt_cali.c battery.c BEKLEMEYi_big.c BEKLEMEYi_small.c freeze.c High_limit.c hsp1.c hsp2.c layout1.c layout2.c limit_icon.c little_standby.c lock_off.c lock_on.c Low_limit.c lung.c MajaX45.c MS.c ms_westfalia.c MSW_LOGO.c MSW_MAJA.c MSW_x45.c New_Siriusmed.c perfemed_logo.c SASVAT_LOGO_1.c SASVAT_LOGO_2.c SASVAT_LOGO_3.c SASVAT_LOGO_4.c silence_icon.c Siriusmed_Care.c Standby_Icon.c Warning.c X45.c X6.c
    ../../photo/: Anesthesia.c Anesthesia_System.c atese.c siriusmed.c vetland.c
  group Application/language
    ../../Application/language/: alarm_str.c str.h system_str.c
  group Application/new icon
    ../../Application/icon/new icon/: 490x140.c x180y224.c x182y170.c x194y166.c x215y224.c x219y170.c x231y166.c x546y174.c
  group board
    ../../board/: sys.c test.c
  group board/DRIVE
    ../../board/device/src/: AD.c CLK.c EMC.c IIC.c LCD1.c LED_GPIO.C NVIC.c PWM.c RTC.c TIM.c UART.c
  group config
    ../../board/include/: iolpc1788 and 2478.h
    Config/: LPC1788 and 2478_Flash.icf
    ./: vectors.s
  group gui/ConvertColor
    ../../GUI/ConvertColor/: LCDP565.c LCDPM565.c
  group gui/Core
    ../../GUI/Core/: GUI.h GUI2DLib.c GUI__AddSpaceHex.c GUI__CalcTextRect.c GUI__DivideRound.c GUI__DivideRound32.c GUI__GetFontSizeY.c GUI__GetNumChars.c GUI__HandleEOLine.c GUI__IntersectRect.c GUI__IntersectRects.c GUI__memset.c GUI__memset16.c GUI__Read.c GUI__ReduceRect.c GUI__SetText.c GUI__strcmp.c GUI__strlen.c GUI__Wrap.c GUI_AddBin.c GUI_AddDec.c GUI_AddDecMin.c GUI_AddDecShift.c GUI_AddHex.c GUI_AddKeyMsgHook.c GUI_ALLOC_AllocInit.c GUI_ALLOC_AllocZero.c GUI_BMP.c GUI_BMP_Serialize.c GUI_CalcColorDist.c GUI_ClearRectEx.c GUI_Color2VisColor.c GUI_ConfDefaults.h GUI_CursorArrowL.c GUI_CursorArrowLI.c GUI_CursorArrowLPx.c GUI_CursorArrowM.c GUI_CursorArrowMI.c GUI_CursorArrowMPx.c GUI_CursorArrowS.c GUI_CursorArrowSI.c GUI_CursorArrowSPx.c GUI_CursorCrossL.c GUI_CursorCrossLI.c GUI_CursorCrossLPx.c GUI_CursorCrossM.c GUI_CursorCrossMI.c GUI_CursorCrossMPx.c GUI_CursorCrossS.c GUI_CursorCrossSI.c GUI_CursorCrossSPx.c GUI_CursorHeaderM.c GUI_CursorHeaderMI.c GUI_CursorHeaderMPx.c GUI_CursorPal.c GUI_CursorPalI.c GUI_DispBin.c GUI_DispCEOL.c GUI_DispChar.c GUI_DispChars.c GUI_DispHex.c GUI_DispString.c GUI_DispStringAt.c GUI_DispStringAtCEOL.c GUI_DispStringHCenter.c GUI_DispStringInRect.c GUI_DispStringInRectEx.c GUI_DispStringInRectMax.c GUI_DispStringInRectWrap.c GUI_DispStringLen.c GUI_DrawBitmap.c GUI_DrawBitmapEx.c GUI_DrawBitmapExp.c GUI_DrawBitmapMag.c GUI_DrawFocusRect.c GUI_DrawGraph.c GUI_DrawGraphEx.c GUI_DrawHLine.c GUI_DrawLine.c GUI_DrawPie.c GUI_DrawPixel.c GUI_DrawPoint.c GUI_DrawPolyline.c GUI_DrawRectEx.c GUI_DrawVLine.c GUI_ErrorOut.c GUI_Exec.c GUI_FillPolygon.c GUI_FillRect.c GUI_FillRectEx.c GUI_FontIntern.h GUI_GetBitmapPixelColor.c GUI_GetBitmapPixelIndex.c GUI_GetClientRect.c GUI_GetColor.c GUI_GetDispPos.c GUI_GetFont.c GUI_GetFontInfo.c GUI_GetFontSizeY.c GUI_GetLineStyle.c GUI_GetStringDistX.c GUI_GetTextAlign.c GUI_GetTextExtend.c GUI_GetTextMode.c GUI_GetVersionString.c GUI_GetYSizeOfFont.c GUI_Goto.c GUI_InitLUT.c GUI_InvertRect.c GUI_IsInFont.c GUI_Log.c GUI_MergeRect.c GUI_MOUSE.c GUI_MOUSE_DriverPS2.c GUI_MoveRect.c GUI_OnKey.c GUI_Pen.c GUI_PID.c GUI_Private.H GUI_Protected.h GUI_RectsIntersect.c GUI_SaveContext.c GUI_SelectLayer.c GUI_SelectLCD.c GUI_SetClipRect.c GUI_SetColor.c GUI_SetColorIndex.c GUI_SetDecChar.c GUI_SetDefault.c GUI_SetDrawMode.c GUI_SetFont.c GUI_SetLBorder.c GUI_SetLineStyle.c GUI_SetLUTColor.c GUI_SetLUTColorEx.c GUI_SetLUTEntry.c GUI_SetOrg.c GUI_SetPixelIndex.c GUI_SetTextAlign.c GUI_SetTextMode.c GUI_SetTextStyle.c GUI_SIF.c GUI_SIF_Prop.c GUI_TOUCH.c GUI_TOUCH_DriverAnalog.c GUI_TOUCH_StoreState.c GUI_TOUCH_StoreUnstable.c GUI_UC.c GUI_UC_DispString.c GUI_UC_EncodeNone.c GUI_UC_EncodeUTF8.c GUI_VNC.h GUI_WaitEvent.c GUI_WaitKey.c GUI_Warn.c GUI_X.h GUIAlloc.c GUIArc.c GUIChar.c GUICharLine.c GUICharM.c GUICharP.c GUICirc.c GUIColor2Index.c GUICore.c GUICurs.c GUIDebug.h GUIEncJS.c GUIIndex2Color.c GUIPolyE.c GUIPolyM.c GUIPolyR.c GUIRealloc.c GUIStream.c GUITask.c GUITime.c GUITimer.c GUIType.h GUIUC0.c GUIVal.c GUIValf.c GUIVersion.h LCD.c LCD.h LCD_API.c LCD_ConfDefaults.h LCD_DrawBitmap_565.c LCD_DrawBitmap_M565.c LCD_DrawVLine.c LCD_GetColorIndex.c LCD_GetEx.c LCD_GetNumDisplays.c LCD_GetPixelColor.c LCD_Index2ColorEx.c LCD_L0_Generic.c LCD_Mirror.c LCD_MixColors256.c LCD_Private.h LCD_Protected.h LCD_Rotate180.c LCD_RotateCCW.c LCD_RotateCW.c LCD_SelectLCD.c LCD_SetAPI.c LCD_SetClipRectEx.c LCD_UpdateColorIndices.c LCDAA.c LCDColor.c LCDGetP.c LCDInfo.c LCDInfo0.c LCDInfo1.c LCDL0Delta.c LCDL0Mag.c LCDP1.c LCDP565_Index2Color.c LCDPM565_Index2Color.c LCDRLE4.c LCDRLE8.c LCDSIM.h
  group gui/Font
    ../../GUI/Font/: Arial_MSYH_16.c F08_1.c F08_ASCII.c F13_1.c F13_ASCII.c F13B_1.c F13B_ASCII.c F24_BatangChe.c F24B_ASCII.c F32B_ASCII.c F6x8.c F8x16.c FD32.c
  group gui/LCDDriver
    ../../GUI/LCDDriver/: LCD_NXP.c LCDWin.c
  group gui/Widget
    ../../GUI/Widget/: BUTTON.c BUTTON.h BUTTON__SetBitmapObj.c BUTTON_Bitmap.c BUTTON_BMP.c BUTTON_Create.c BUTTON_CreateIndirect.c BUTTON_Default.c BUTTON_Get.c BUTTON_IsPressed.c BUTTON_Private.h BUTTON_SelfDraw.c BUTTON_SetTextAlign.c BUTTON_StreamedBitmap.c CHECKBOX.c CHECKBOX.h CHECKBOX_Create.c CHECKBOX_CreateIndirect.c CHECKBOX_Default.c CHECKBOX_GetState.c CHECKBOX_Image.c CHECKBOX_IsChecked.c CHECKBOX_Private.h CHECKBOX_SetBkColor.c CHECKBOX_SetDefaultImage.c CHECKBOX_SetFont.c CHECKBOX_SetImage.c CHECKBOX_SetNumStates.c CHECKBOX_SetSpacing.c CHECKBOX_SetState.c CHECKBOX_SetText.c CHECKBOX_SetTextAlign.c CHECKBOX_SetTextColor.c DIALOG.c DIALOG.h DIALOG_Intern.h DROPDOWN.c DROPDOWN.h DROPDOWN_Create.c DROPDOWN_CreateIndirect.c DROPDOWN_DeleteItem.c DROPDOWN_InsertString.c DROPDOWN_ItemSpacing.c DROPDOWN_Private.h DROPDOWN_SetAutoScroll.c DROPDOWN_SetTextAlign.c DROPDOWN_SetTextHeight.c EDIT.c EDIT.h EDIT_Create.c EDIT_CreateIndirect.c EDIT_Default.c EDIT_GetNumChars.c EDIT_Private.h EDIT_SetCursorAtChar.c EDIT_SetInsertMode.c EDIT_SetpfAddKeyEx.c EDIT_SetpfUpdateBuffer.c EDIT_SetSel.c EDITBin.c EDITDec.c EDITFloat.c EDITHex.c FRAMEWIN.c FRAMEWIN.h FRAMEWIN__UpdateButtons.c FRAMEWIN_AddMenu.c FRAMEWIN_Button.c FRAMEWIN_ButtonClose.c FRAMEWIN_ButtonMax.c FRAMEWIN_ButtonMin.c FRAMEWIN_Create.c FRAMEWIN_CreateIndirect.c FRAMEWIN_Default.c FRAMEWIN_Get.c FRAMEWIN_IsMinMax.c FRAMEWIN_MinMaxRest.c FRAMEWIN_Private.h FRAMEWIN_SetBorderSize.c FRAMEWIN_SetColors.c FRAMEWIN_SetFont.c FRAMEWIN_SetResizeable.c FRAMEWIN_SetTitleHeight.c FRAMEWIN_SetTitleVis.c GRAPH.c GRAPH.h GRAPH_CreateIndirect.c GRAPH_DATA_XY.c GRAPH_DATA_YT.c GRAPH_Private.h GRAPH_SCALE.c GUI_ARRAY.c GUI_ARRAY.h GUI_ARRAY_DeleteItem.c GUI_ARRAY_InsertItem.c GUI_ARRAY_ResizeItem.c GUI_DRAW.c GUI_DRAW_BITMAP.c GUI_DRAW_BMP.c GUI_DRAW_Self.c GUI_DRAW_STREAMED.c GUI_EditBin.c GUI_EditDec.c GUI_EditFloat.c GUI_EditHex.c GUI_EditString.c GUI_HOOK.c GUI_HOOK.h HEADER.c HEADER.h HEADER__SetDrawObj.c HEADER_Bitmap.c HEADER_BMP.c HEADER_Create.c HEADER_CreateIndirect.c HEADER_Private.h HEADER_StreamedBitmap.c LISTBOX.c LISTBOX.h LISTBOX_Create.c LISTBOX_CreateIndirect.c LISTBOX_Default.c LISTBOX_DeleteItem.c LISTBOX_Font.c LISTBOX_GetItemText.c LISTBOX_GetNumItems.c LISTBOX_InsertString.c LISTBOX_ItemDisabled.c LISTBOX_ItemSpacing.c LISTBOX_MultiSel.c LISTBOX_Private.h LISTBOX_ScrollStep.c LISTBOX_SetAutoScroll.c LISTBOX_SetBkColor.c LISTBOX_SetOwner.c LISTBOX_SetOwnerDraw.c LISTBOX_SetScrollbarWidth.c LISTBOX_SetString.c LISTBOX_SetTextColor.c LISTVIEW.c LISTVIEW.h LISTVIEW_Create.c LISTVIEW_CreateIndirect.c LISTVIEW_Default.c LISTVIEW_DeleteColumn.c LISTVIEW_DeleteRow.c LISTVIEW_GetBkColor.c LISTVIEW_GetFont.c LISTVIEW_GetHeader.c LISTVIEW_GetNumColumns.c LISTVIEW_GetNumRows.c LISTVIEW_GetSel.c LISTVIEW_GetTextColor.c LISTVIEW_Private.h LISTVIEW_SetBkColor.c LISTVIEW_SetColumnWidth.c LISTVIEW_SetFont.c LISTVIEW_SetGridVis.c LISTVIEW_SetItemColor.c LISTVIEW_SetItemText.c LISTVIEW_SetLBorder.c LISTVIEW_SetRBorder.c LISTVIEW_SetRowHeight.c LISTVIEW_SetSel.c LISTVIEW_SetTextAlign.c LISTVIEW_SetTextColor.c MENU.c MENU.h MENU__FindItem.c MENU_Attach.c MENU_CreateIndirect.c MENU_Default.c MENU_DeleteItem.c MENU_DisableItem.c MENU_EnableItem.c MENU_GetItem.c MENU_GetItemText.c MENU_GetNumItems.c MENU_InsertItem.c MENU_Popup.c MENU_Private.h MENU_SetBkColor.c MENU_SetBorderSize.c MENU_SetFont.c MENU_SetItem.c MENU_SetTextColor.c MESSAGEBOX.c MESSAGEBOX.h MULTIEDIT.c MULTIEDIT.h MULTIEDIT_Create.c MULTIEDIT_CreateIndirect.c MULTIPAGE.c MULTIPAGE.h MULTIPAGE_Create.c MULTIPAGE_CreateIndirect.c MULTIPAGE_Default.c MULTIPAGE_Private.h PROGBAR.c PROGBAR.h PROGBAR_Create.c PROGBAR_CreateIndirect.c RADIO.c RADIO.h RADIO_Create.c RADIO_CreateIndirect.c RADIO_Default.c RADIO_Image.c RADIO_Private.h RADIO_SetBkColor.c RADIO_SetDefaultImage.c RADIO_SetFont.c RADIO_SetGroupId.c RADIO_SetImage.c RADIO_SetText.c RADIO_SetTextColor.c SCROLLBAR.c SCROLLBAR.h SCROLLBAR_Create.c SCROLLBAR_CreateIndirect.c SCROLLBAR_Defaults.c SCROLLBAR_GetValue.c SCROLLBAR_Private.h SCROLLBAR_SetWidth.c SLIDER.c SLIDER.h SLIDER_Create.c SLIDER_CreateIndirect.c TEXT.c TEXT.h TEXT_Create.c TEXT_CreateIndirect.c TEXT_Private.h TEXT_SetBkColor.c TEXT_SetFont.c TEXT_SetText.c TEXT_SetTextAlign.c TEXT_SetTextColor.c WIDGET.c WIDGET.h WIDGET_Effect_3D.c WIDGET_Effect_3D1L.c WIDGET_Effect_3D2L.c WIDGET_Effect_None.c WIDGET_Effect_Simple.c WIDGET_FillStringInRect.c WIDGET_SetEffect.c WIDGET_SetWidth.c WINDOW.c WINDOW_Default.c WINDOW_Private.h
  group gui/WM
    ../../GUI/WM/: WM.c WM.h WM__ForEachDesc.c WM__GetFirstSibling.c WM__GetFocussedChild.c WM__GetLastSibling.c WM__GetOrg_AA.c WM__GetPrevSibling.c WM__IsAncestor.c WM__IsChild.c WM__IsEnabled.c WM__NotifyVisChanged.c WM__Screen2Client.c WM__SendMessage.c WM__SendMessageIfEnabled.c WM__SendMessageNoPara.c WM__UpdateChildPositions.c WM_AttachWindow.c WM_BringToBottom.c WM_BringToTop.c WM_Broadcast.c WM_CheckScrollPos.c WM_CriticalHandle.c WM_DIAG.c WM_EnableWindow.c WM_ForEachDesc.c WM_GetBkColor.c WM_GetClientRect.c WM_GetClientWindow.c WM_GetDesktopWindow.c WM_GetDesktopWindowEx.c WM_GetDiagInfo.c WM_GetDialogItem.c WM_GetFirstChild.c WM_GetFlags.c WM_GetFocussedWindow.c WM_GetId.c WM_GetInsideRect.c WM_GetInsideRectExScrollbar.c WM_GetInvalidRect.c WM_GetNextSibling.c WM_GetOrg.c WM_GetParent.c WM_GetPrevSibling.c WM_GetScrollbar.c WM_GetScrollPartner.c WM_GetScrollState.c WM_GetWindowRect.c WM_GetWindowSize.c WM_GUI.h WM_HasCaptured.c WM_HasFocus.c WM_Hide.c WM_Intern.h WM_Intern_ConfDep.h WM_IsCompletelyVisible.c WM_IsEnabled.c WM_IsFocussable.c WM_IsVisible.c WM_IsWindow.c WM_MakeModal.c WM_Move.c WM_MoveChildTo.c WM_NotifyParent.c WM_OnKey.c WM_Paint.c WM_PID__GetPrevState.c WM_ResizeWindow.c WM_Screen2Win.c WM_SendMessageNoPara.c WM_SendToParent.c WM_SetAnchor.c WM_SetCallback.c WM_SetCapture.c WM_SetCaptureMove.c WM_SetCreateFlags.c WM_SetDesktopColor.c WM_SetFocus.c WM_SetFocusOnNextChild.c WM_SetFocusOnPrevChild.c WM_SetId.c WM_SetpfPollPID.c WM_SetScrollbar.c WM_SetScrollState.c WM_SetSize.c WM_SetTrans.c WM_SetTransState.c WM_SetUserClipRect.c WM_SetWindowPos.c WM_SetXSize.c WM_SetYSize.c WM_Show.c WM_StayOnTop.c WM_Timer.c WM_TimerExternal.c WM_UserData.c WM_Validate.c WM_ValidateWindow.c WMMemDev.c WMTouch.c
  group GUI_X
    ../../GUI_X/: GUI_X.c
  group GUIConfig
    ../../guiconfig/: GUIConf.h GUITouchConf.h LCDConf.h
